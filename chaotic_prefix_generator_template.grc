<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>chaotic_prefix_generator_template</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_delay</value></param>
<param><key>value</key><value>1+(taps_per_filt-1)/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_per_filt</value></param>
<param><key>value</key><value>len(tx_rrc_taps)/nfilts</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Init</value></param>
<param><key>label</key><value>initial_condition</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Map_parameter</value></param>
<param><key>label</key><value>Map_parameter</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.98</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>Multiply</value></param>
<param><key>label</key><value>Multiply</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/edwin/Desktop/filetest_prefix</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vector</key><value>chaos.chaotic_prefix_bc(0.8,3.98,50,'len_tag_key')</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>impMod</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
if __name__ == '__main__':
    import ctypes
from gnuradio import blocks
from gnuradio import gr
from gnuradio.filter import firdes
from gnuradio.filter import pfb
import chaos
import numpy



class chaotic_prefix_generator(gr.top_block):
    def Logistic_map(self,Init, Map_parameter, seq_len):
	chaotic_seq=[]
	chaotic_seq.append(Init)
        summation=Init
	for i in range(1,seq_len):
	  x_nn=Map_parameter*chaotic_seq[i-1]*(1-chaotic_seq[i-1])
   	  summation+=x_nn        
	  chaotic_seq.append(x_nn)
	summation=summation/seq_len
   	maxabs=0
 	for i in range(seq_len):
	  chaotic_seq[i]-=summation
	  if(abs(chaotic_seq[i])&gt;maxabs):
	    maxabs=abs(chaotic_seq[i])
	for i in range(seq_len):
	  chaotic_seq[i]=chaotic_seq[i]/maxabs	
	return chaotic_seq
    def __init__(self, Multiply=1, sps=4, Map_parameter=3.63, mean=0.5, Init=0.8, spreading_gain=128):
	gr.top_block.__init__(self,'Chaotic Prefix Generator')
	## Variables############
        self.nfilts=nfilts=32
	self.eb=eb=1
	self.tx_rrc_taps=tx_rrc_taps=firdes.root_raised_cosine(nfilts, nfilts, 1.0, eb, 11*sps*nfilts)
	self.taps_per_filt=taps_per_filt = len(tx_rrc_taps)/nfilts
	self.samp_rate=samp_rate = 32000
	self.filt_delay=filt_delay = 1+(taps_per_filt-1)/2
	self.chaotic_seq=chaotic_seq=self.Logistic_map(Init,Map_parameter,spreading_gain)
	##Blocks################
	self.pfb_arb_resampler_xxx_0 = pfb.arb_resampler_ccf(
        	  sps,
                  taps=(tx_rrc_taps),
        	  flt_size=nfilts)
	self.pfb_arb_resampler_xxx_0.declare_sample_delay(filt_delay)
	#self.chaos_chaotic_seq_source_f_0 = chaos.chaotic_seq_source_f(
	#	Init,
	#	spreading_gain, 
	 #       Map_parameter, [], False)
	self.blocks_vector_source_x_0 = blocks.vector_source_c(chaotic_seq, False, 1, [])
	self.blocks_vector_sink_x_0 = blocks.vector_sink_c(1)
	#self.blocks_multiply_const_vxx_0 = blocks.multiply_const_vcc((Multiply, ))
	#self.blocks_float_to_complex_0 = blocks.float_to_complex(1)
	#self.blocks_add_const_vxx_0 = blocks.add_const_vcc((-mean, ))

	##Connections###############
	#self.connect((self.chaos_chaotic_seq_source_f_0,0),(self.blocks_float_to_complex_0,0))
	#elf.connect((self.blocks_float_to_complex_0, 0), (self.blocks_add_const_vxx_0, 0))
	#self.connect((self.blocks_vector_source_x_0, 0), (self.blocks_add_const_vxx_0, 0))       
	#self.connect((self.blocks_add_const_vxx_0, 0), (self.blocks_multiply_const_vxx_0, 0))
        #self.connect((self.blocks_multiply_const_vxx_0, 0), (self.pfb_arb_resampler_xxx_0, 0))
	self.connect((self.blocks_vector_source_x_0,0),(self.pfb_arb_resampler_xxx_0,0))	
        self.connect((self.pfb_arb_resampler_xxx_0, 0), (self.blocks_vector_sink_x_0, 0))
    def main(self):
	
	self.run()
	data=self.blocks_vector_sink_x_0.data()
	#print data
	self.stop()
	return data

if __name__=='__main__':
	chaotic_prefix_generator().main()
	

</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import chaos</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mean</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spreading_gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
